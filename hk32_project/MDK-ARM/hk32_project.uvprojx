# Keil uVision project hk32_project.uvprojx, settings and files
target hk32_project (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: hk32_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F1xx
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./Algorithm;./Application;./Bsp;./System;./Task
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
    ./hk32_project/: hk32_project.map
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Algorithm
    ./Algorithm/: algorithm.cpp string_algorithm.cpp ring_queue.cpp
  group Application
    ./Application/: batVolt.cpp A7680C.cpp handler.cpp bms.cpp periph_control.cpp rgb.cpp low_power.cpp
  group Bsp
    ./Bsp/: bsp.cpp bsp_adc.cpp bsp_buzzer.cpp bsp_can.cpp bsp_key.cpp bsp_rgb.cpp bsp_usart.cpp bsp_rtc.cpp
  group System
    ./System/: variables.cpp callback.cpp MillisTaskManager.cpp System.cpp state_machine.cpp
  group Task
    ./Task/: A7680_Task.cpp main_task.cpp bms_task.cpp rgb_task.cpp stateMachine_Task.cpp
software components: CMSIS:CORE 6.1.0
