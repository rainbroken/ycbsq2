# Keil uVision project HK32F0xxA_Demo.uvprojx, settings and files
target HK32F04AxxA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F103C8 HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HK32F0xxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F04AxxA,USE_HK32F0xxA_EVAL
  c include: ..\..\..\..\..\Libraries\CMSIS\HK32F0xxA\Include;..\..\..\..\..\Libraries\HK32F0xxA_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\CM0\Core;..\inc;..\..\..\..\..\Boards\Board_HK32F0xxA_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../../../Libraries/CMSIS/HK32F0xxA/Source/ARM/: startup_hk32asafex.s startup_hk32aspinx.s startup_hk32f04axxa.s startup_hk32f030xxa.s startup_hk32f031xxa.s startup_hk32f072x.s
  group USER
    ./../src/: hk32f0xxa_it.c main.c
    ../../../../../Libraries/CMSIS/HK32F0xxA/Source/: system_hk32f0xxa.c
  group STD_LIB
    ../../../../../Libraries/HK32F0xxA_StdPeriphDriver/src/: hk32f0xxa_adc.c hk32f0xxa_aes.c hk32f0xxa_can.c hk32f0xxa_clu.c hk32f0xxa_comp.c hk32f0xxa_crc.c hk32f0xxa_dbgmcu.c hk32f0xxa_divsqrt.c hk32f0xxa_dma.c hk32f0xxa_emacc.c hk32f0xxa_exti.c hk32f0xxa_flash.c hk32f0xxa_gpio.c hk32f0xxa_hash.c hk32f0xxa_i2c.c hk32f0xxa_iwdg.c hk32f0xxa_lpuart.c hk32f0xxa_misc.c hk32f0xxa_pwr.c hk32f0xxa_rcc.c hk32f0xxa_rtc.c hk32f0xxa_spi.c hk32f0xxa_syscfg.c hk32f0xxa_trng.c hk32f0xxa_tim.c hk32f0xxa_usart.c hk32f0xxa_wwdg.c
  group Boards
    ../../../../../Boards/Board_HK32F0xxA_EVAL/: hk32f0xxa_eval.c hk32f0xxa_eval_i2c_ee.c hk32f0xxa_eval_i2c_tsensor.c hk32f0xxa_eval_spi_sd.c
  group Doc
    ../: Readme.txt
target HK32F030xxA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F030C8TxA HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.2
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F0xxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F030xxA,USE_HK32F0xxA_EVAL
  c include: ..\..\..\..\..\Libraries\CMSIS\HK32F0xxA\Include;..\..\..\..\..\Libraries\HK32F0xxA_StdPeriphDriver\\inc;..\..\..\..\..\Libraries\CMSIS\CM0\Core;..\inc;..\..\..\..\..\Boards\Board_HK32F0xxA_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target HK32F031xxA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F031C6TxA HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.2
  cpu: as above
  output: HK32F0xxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F031xxA,USE_HK32F0xxA_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target HK32F072x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F072CBTx HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.2
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x0001F000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F0xxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F072x,USE_HK32F0xxA_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x2800
target HK32ASpin010xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32ASPIN010CBTx HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.2
  cpu: as above
  output: HK32F0xxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32ASPIN010xx,USE_HK32F0xxA_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x2800
target HK32ASafe010xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32ASAFE010CBTx HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.2
  cpu: as above
  output: HK32F0xxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32ASAFE010xx,USE_HK32F0xxA_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x2800
