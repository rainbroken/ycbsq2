# IAR project HK32F0xxA_Demo.ewp, settings and files
configuration HK32F04AxxA (ARM, debug)
  General.OGChipSelectEditMenu: HK32F04ARBA HK HK32F04ARBA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HK32F04AxxA; USE_HK32F0xxA_EVAL
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\CMSIS\HK32F0xxA\Include; ..\..\..\..\..\Libraries\HK32F0xxA_StdPeriphDriver\inc; ..\inc; ..\..\..\..\..\Boards\Board_HK32F0xxA_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HK32F0xxA_Demo.srec
  ILINK.IlinkOutputFile: HK32F0xxA_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HK32F030xxA (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HK32F030R8A HK HK32F030R8A
  ICCARM.CCDefines: HK32F030xxA
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\CMSIS\HK32F0xxA\Include; ..\..\..\..\..\Libraries\HK32F0xxA_StdPeriphDriver\inc; ..\inc
configuration HK32F031xxA (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HK32F031C6A HK HK32F031C6A
  ICCARM.CCDefines: HK32F031xxA
  ICCARM.CCIncludePath2: as above
configuration HK32F072x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HK32F072RB HK HK32F072RB
  ICCARM.CCDefines: HK32F072x
  ICCARM.CCIncludePath2: as above
configuration HK32ASpin010xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HK32ASPIN010RB HK HK32ASPIN010RB
  ICCARM.CCDefines: HK32ASPIN010xx
  ICCARM.CCIncludePath2: as above
configuration HK32ASafe010xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HK32ASAFE010RB HK HK32ASAFE010RB
  ICCARM.CCDefines: HK32ASAFE010xx
  ICCARM.CCIncludePath2: as above
  group (top)
    ../: Readme.txt
  group Boards
    ../../../../../Boards/Board_HK32F0xxA_EVAL/: hk32f0xxa_eval.c hk32f0xxa_eval_i2c_ee.c hk32f0xxa_eval_i2c_tsensor.c hk32f0xxa_eval_spi_sd.c
  group CMSIS
    ../../../../../Libraries/CMSIS/HK32F0xxA/Source/IAR/: IAR_Startup_hk32asafex.s IAR_Startup_hk32aspinx.s IAR_Startup_hk32f030xxa.s IAR_Startup_hk32f031xxa.s IAR_Startup_hk32f04axxa.s IAR_Startup_hk32f072x.s
  group HK32F0xxA_Lib
    ../../../../../Libraries/HK32F0xxA_StdPeriphDriver/src/: hk32f0xxa_adc.c hk32f0xxa_aes.c hk32f0xxa_can.c hk32f0xxa_clu.c hk32f0xxa_comp.c hk32f0xxa_crc.c hk32f0xxa_dbgmcu.c hk32f0xxa_divsqrt.c hk32f0xxa_dma.c hk32f0xxa_emacc.c hk32f0xxa_exti.c hk32f0xxa_flash.c hk32f0xxa_gpio.c hk32f0xxa_hash.c hk32f0xxa_i2c.c hk32f0xxa_iwdg.c hk32f0xxa_lpuart.c hk32f0xxa_misc.c hk32f0xxa_pwr.c hk32f0xxa_rcc.c hk32f0xxa_rtc.c hk32f0xxa_spi.c hk32f0xxa_syscfg.c hk32f0xxa_tim.c hk32f0xxa_trng.c hk32f0xxa_usart.c hk32f0xxa_wwdg.c
  group User
    ../src/: hk32f0xxa_it.c main.c
    ../../../../../Libraries/CMSIS/HK32F0xxA/Source/: system_hk32f0xxa.c
