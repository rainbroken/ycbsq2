# Keil uVision project ycbsq2.uvprojx, settings and files
target project (ARM-ADS)
  device: HK32F04ARBTxA HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x0001F000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ycbsq2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x2800
