# Keil uVision project hk32_template.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: HK32F103C8 HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hk32_template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
