# Keil uVision project ycbsq2.uvprojx, settings and files
target ycbsq2 (6220000::V6.22::ARMCLANG)
  device: HK32F04ARBTxA HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x0001F000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ycbsq2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,HK32F04AxxA,USE_HK32F0xxA_EVAL
  c misc: -Wno-deprecated-register
  c include: ..\Drivers\CMSIS\HK32F0xxA\Include;..\Drivers\HK32F0xxA_StdPeriphDriver\inc;..\Drivers\CMSIS\CM0\Core;..\Core\Inc;..\Boards\Board_HK32F0xxA_EVAL;.\User\Algorithm;.\User\Application;.\User\Bsp;.\User\System;.\User\Task
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ../Core/Inc/: hk32f0xxa_conf.h hk32f0xxa_it.h main.h
  group Application/Core
    ../Core/Src/: main.c gpio.cpp adc.cpp can.cpp tim.cpp usart.cpp iic.cpp hk32f0xxa_it.c dma.cpp
    ../Drivers/CMSIS/HK32F0xxA/Source/: system_hk32f0xxa.c
  group Application/Boards
    ../Boards/Board_HK32F0xxA_EVAL/: hk32f0xxa_eval.c hk32f0xxa_eval_i2c_ee.c hk32f0xxa_eval_i2c_tsensor.c hk32f0xxa_eval_spi_flash.c hk32f0xxa_eval_spi_sd.c
  group Drivers/HK32F0xxA_StdPeriphDriver
    ../Libraries/HK32F0xxA_StdPeriphDriver/src/: hk32f0xxa_adc.c hk32f0xxa_aes.c hk32f0xxa_can.c hk32f0xxa_clu.c hk32f0xxa_comp.c hk32f0xxa_crc.c hk32f0xxa_dbgmcu.c hk32f0xxa_divsqrt.c hk32f0xxa_dma.c hk32f0xxa_emacc.c hk32f0xxa_exti.c hk32f0xxa_flash.c hk32f0xxa_gpio.c hk32f0xxa_hash.c hk32f0xxa_i2c.c hk32f0xxa_iwdg.c hk32f0xxa_lpuart.c hk32f0xxa_misc.c hk32f0xxa_pwr.c hk32f0xxa_rcc.c hk32f0xxa_rtc.c hk32f0xxa_spi.c hk32f0xxa_syscfg.c hk32f0xxa_tim.c hk32f0xxa_trng.c hk32f0xxa_usart.c hk32f0xxa_wwdg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/HK32F0xxA/Source/ARM/: startup_hk32f04axxa.s
  group User/Algorithm
    ./User/Algorithm/: algorithm.cpp ring_queue.cpp string_algorithm.cpp
  group User/Application
    ./User/Application/: A7680C.cpp batVolt.cpp bms.cpp handler.cpp low_power.cpp periph_control.cpp rgb.cpp OLED.cpp OLED_Data.cpp
  group User/Bsp
    ./User/Bsp/: bsp_adc.cpp bsp_can.cpp bsp_key.cpp bsp_usart.cpp bsp_rgb.cpp
  group User/System
    ./User/System/: config.cpp callback.cpp MillisTaskManager.cpp state_machine.cpp System.cpp variables.cpp
  group User/Task
    ./User/Task/: A7680_Task.cpp bms_task.cpp main_task.cpp rgb_task.cpp stateMachine_Task.cpp
